## config/boards/shields/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

config ZMK_KEYBOARD_NAME
    default "Macropad 6x6"
    
endif
```
